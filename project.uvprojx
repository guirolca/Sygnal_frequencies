# Keil uVision project project.uvprojx, settings and files
target STM32F429_DISCOVERY (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1
  c define: STM32F429xx,USE_HAL_DRIVER,ARM_MATH_CM4,__FPU_PRESENT=1,STM32F4XX,STM32F429_DISCOVERY,HSE_VALUE=8000000,RCC_OSCILLATORTYPE=RCC_OSCILLATORTYPE_HSE,RCC_PLLSOURCE=RCC_PLLSOURCE_HSE,RCC_PLLM=8,RCC_PLLN=360,RCC_PLLP=2,RCC_PLLQ=7,
  c include: .\User;.\TM;..\00-STM32_LIBRARIES;..\00-HAL_DRIVERS\STM32F4xx_HAL_Driver\Inc;..\00-HAL_DRIVERS\CMSIS\Device\ST\STM32F4xx\Include;..\00-HAL_DRIVERS\CMSIS\Include;..\00-STM32_LIBRARIES\USB_Host;..\00-STM32_LIBRARIES\USB_Host\Core\Inc;..\00-STM32_LIBRARIES\USB_Host\Class\HID\Inc;..\00-STM32_LIBRARIES\USB_Host\Class\MSC\Inc;..\00-STM32_LIBRARIES\fatfs;..\00-STM32_LIBRARIES\fatfs\option;..\00-STM32_LIBRARIES\fatfs\drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ./Libraries/00-HAL_DRIVERS/cmsis/device/st/stm32f4xx/Include/: stm32f4xx.h
  group STM32F4_Startup
    ./Libraries/00-HAL_DRIVERS/cmsis/device/st/stm32f4xx/source/templates/arm/: startup_stm32f446xx.s
  group STM32F4_HAL_Drivers
    ./Libraries/00-HAL_DRIVERS/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_ll_usb.c stm32f4xx_hal_spi.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c
  group TM
    ./Libraries/00-STM32_LIBRARIES/: tm_stm32_delay.c tm_stm32_disco.c tm_stm32_fatfs.c tm_stm32_fonts.c tm_stm32_gpio.c tm_stm32_i2c.c tm_stm32_mpu6050.c tm_stm32_rcc.c tm_stm32_rtc.c tm_stm32_spi.c tm_stm32_usb.c tm_stm32_buffer.c tm_stm32f4_bkpsram.c tm_stm32_usb_host.c tm_stm32_usb_host_msc.c
  group User
    ./User/: main.h main.c stm32fxxx_it.c stm32fxxx_it.h system_stm32f4xx.c stm32f4xx_hal_msp.c Config.c Funciones.c USBfunc.c TC.c
    ./Libraries/FSUPV/: ALE_Buffer.c ALE_GPIO_F4.c ALE_GPS.c ALE_TIM.c ALE_USART_F4.c crc.c packet.c
  group USB HOST
    ./Libraries/00-STM32_LIBRARIES/USB_Host/Core/Src/: usbh_conf.c usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group USB HOST MSC Class
    ./Libraries/00-STM32_LIBRARIES/USB_Host/class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group FATFS
    ./Libraries/00-STM32_LIBRARIES/fatfs/: diskio.c ff.c ff_gen_drv.c
    ./Libraries/00-STM32_LIBRARIES/fatfs/option/: syscall.c unicode.c
    ./Libraries/00-STM32_LIBRARIES/fatfs/drivers/: fatfs_usb.c
target STM32F4_DISCOVERY (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=3 oTime=1
  c define: STM32F407xx,USE_HAL_DRIVER,ARM_MATH_CM4,__FPU_PRESENT=1,STM32F4XX,STM32F4_DISCOVERY,HSE_VALUE=8000000,RCC_OSCILLATORTYPE=RCC_OSCILLATORTYPE_HSE,RCC_PLLM=8,RCC_PLLN=336,RCC_PLLP=2,RCC_PLLQ=7,
  c include: .\User;.\TM;.\Libraries\00-HAL_DRIVERS\STM32F4xx_HAL_Driver\Inc;.\Libraries\00-STM32_LIBRARIES;.\Libraries\00-STM32_LIBRARIES\USB_Host\Core\Inc;.\Libraries\00-STM32_LIBRARIES\USB_Host\class\MSC\Inc;.\Libraries\00-STM32_LIBRARIES\fatfs;.\Libraries\00-STM32_LIBRARIES\fatfs\drivers;.\Libraries\00-STM32_LIBRARIES\fatfs\option;.\Libraries\FSUPV;.\Libraries\00-HAL_DRIVERS\cmsis\Include;.\Libraries\00-HAL_DRIVERS\cmsis\device\st\stm32f4xx\Include;.\Libraries\00-STM32_LIBRARIES\USB_Device\Core\Inc;.\Libraries\00-STM32_LIBRARIES\USB_Device\class\MSC\Inc;.\Libraries\00-STM32_LIBRARIES\USB_Device;.\Libraries\00-STM32_LIBRARIES\USB_Device\Class\CDC\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target STM32F401_DISCOVERY (ARM-ADS)
  device: STM32F401VCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1
  c define: STM32F401xC,USE_HAL_DRIVER,ARM_MATH_CM4,__FPU_PRESENT=1,STM32F4XX,STM32F401_DISCOVERY,HSE_VALUE=8000000,RCC_OSCILLATORTYPE=RCC_OSCILLATORTYPE_HSE,RCC_PLLM=8,RCC_PLLN=336,RCC_PLLP=4,RCC_PLLQ=7,
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
target STM32F411_DISCOVERY (ARM-ADS)
  device: STM32F411VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: as above
  output: project +hex
  c flags: Optim=1
  c define: STM32F411xE,USE_HAL_DRIVER,ARM_MATH_CM4,__FPU_PRESENT=1,STM32F4XX,STM32F411_DISCOVERY,HSE_VALUE=8000000,RCC_OSCILLATORTYPE=RCC_OSCILLATORTYPE_HSE,RCC_PLLM=8,RCC_PLLN=400,RCC_PLLP=4,RCC_PLLQ=7,
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target STM32F439_EVAL (ARM-ADS)
  device: STM32F439NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: as above
  output: project +hex
  c flags: Optim=1
  c define: STM32F439xx,USE_HAL_DRIVER,ARM_MATH_CM4,__FPU_PRESENT=1,STM32F4XX,STM32F439_EVAL,HSE_VALUE=25000000,RCC_OSCILLATORTYPE=RCC_OSCILLATORTYPE_HSE,RCC_PLLM=25,RCC_PLLN=400,RCC_PLLP=4,RCC_PLLQ=7,
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
target STM32F7_DISCOVERY (ARM-ADS)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.12.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1
  c define: STM32F746xx,USE_HAL_DRIVER,ARM_MATH_CM7,__FPU_PRESENT=1,STM32F7XX,STM32F7_DISCOVERY,HSE_VALUE=25000000,RCC_OSCILLATORTYPE=RCC_OSCILLATORTYPE_HSE,RCC_PLLSOURCE=RCC_PLLSOURCE_HSE,RCC_PLLM=25,RCC_PLLN=400,RCC_PLLP=2,RCC_PLLQ=8
  c include: .\User;.\TM;..\00-STM32_LIBRARIES;..\00-HAL_DRIVERS\STM32F7xx_HAL_Driver\Inc;..\00-HAL_DRIVERS\CMSIS\Device\ST\STM32F7xx\Include;..\00-HAL_DRIVERS\CMSIS\Include;..\00-STM32_LIBRARIES\USB_Host;..\00-STM32_LIBRARIES\USB_Host\Core\Inc;..\00-STM32_LIBRARIES\USB_Host\Class\HID\Inc;..\00-STM32_LIBRARIES\USB_Host\Class\MSC\Inc;..\00-STM32_LIBRARIES\fatfs;..\00-STM32_LIBRARIES\fatfs\drivers;..\00-STM32_LIBRARIES\fatfs\option
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
